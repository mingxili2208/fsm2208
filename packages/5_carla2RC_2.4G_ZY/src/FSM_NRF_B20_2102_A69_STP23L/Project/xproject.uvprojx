# Keil uVision project xproject.uvprojx, settings and files
target XTARK_ROBOT (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xproject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Robot;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM3;..\Driver\ax_oled;..\Driver\stp23l;..\Driver\a69
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Robot
    ../Robot/: main.c FreeRTOSConfig.h stm32f10x_it.c system_stm32f10x.c ax_kinematics.c ax_light.c ax_robot.c ax_speed.c ax_control.c ax_akm.c
  group Driver
    ../Driver/: ax_delay.c ax_led.c ax_beep.c ax_key.c ax_sys.c ax_vin.c ax_motor.c ax_encoder.c ax_servo.c ax_mpu6050.c ax_uart1.c ax_uart2.c ax_uart4.c ax_rgb.c ax_sbus.c ax_ps2.c spi.c 24l01.c
    ../Driver/ax_oled/: ax_oled.c
    ../Driver/stp23l/: usart3.c usart4.c
    ../Driver/a69/: a69.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMISS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Doc
    ../Doc/: ax_readme.txt
